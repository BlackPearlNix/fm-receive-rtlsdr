options:
  parameters:
    generate_options: qt_gui
    id: fm_rtlsdr
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audioGain
  id: variable_qtgui_range
  parameters:
    label: Amplify
    start: '0.5'
    step: '0.25'
    stop: '5'
    value: '1'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Center Frequency
    start: '88000000'
    step: '100000'
    stop: '108000000'
    value: '91100000'
  states: {}
- name: mod
  id: variable_qtgui_chooser
  parameters:
    label: De Modulation type
    label0: Inbuilt
    label1: Custom
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '49'
    value: '47'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: 192e3
    tau: '75e-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    comment: |-
      FM broadcast channels allocated 200 kHz
      Therefore we want to process as much of 
      that bandwidth as possible with the FM demodulator
    quad_rate: 192e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audioGain
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mod
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '0.5'
    samp_rate: 192e3
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: (2,1)
    name: '"Received Spectrum"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '48000'
    fc: '0'
    fftsize: '1024'
    gui_hint: (2,2)
    name: '"Demodulated Audio Spectrum"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Received Signal"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '1'
    type: fff
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: rfGain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', low_pass_filter_0, '0']
- [analog_wfm_rcv_0, '0', blocks_selector_0, '0']
- [blocks_complex_to_arg_0, '0', analog_fm_deemph_0, '0']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_selector_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', blocks_delay_0, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_selector_0, '1']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
